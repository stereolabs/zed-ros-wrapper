Commit message: Added ZED2 STL

File: zed_wrapper/urdf/zed2.urdf (robot description, URDF)
Before this commit: robot zed2_camera, 6 links, 5 joints
Links:
- link zed_camera_center: geometry visual mesh filename=package://zed_wrapper/urdf/models/ZED2.stl
